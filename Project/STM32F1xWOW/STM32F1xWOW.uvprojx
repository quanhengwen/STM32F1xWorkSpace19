# Keil uVision project STM32F1xWOW.uvprojx, settings and files
target DEMO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Driver\Tool;..\..\Examples\DEMO\include;..\..\Examples\WOW
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MAIN
    ./main/: main.c STM32_IT.c STM32_WOW.C
  group APP
    ../../Examples/WOW/: A3987_TEST.C ADC_Temperature.C ADC_TEST.C Buzzer_TEST.C CAN_TEST.C CD4511BM_TEST.C DAC_TEST.C FX2N_14MR.C IAP.C ICCARD.C LK3U_40MR.C OFFLINE_ISP.C OLED096_TEST.C PWM_LED.C PWM_TEST.C PwrTest.C R2A15908SP.C SPI_TEST.C SPItoUSART.C SteepMotorTest.C STM32_LCD.C STM32F103C8T6.C SysTick_TEST.C TEST.C TIM_TEST.C TM1618_TEST.C TM1638_TEST.C USART_TEST.C USBTEST_RS485TOUSART.C USBtoSPI.C VirtualCom.C SWDTEST.C CS5530_DEMO.C FatFsTest.C MmcSDTest.C FSMCTest.C USBDEMO.C AMPTest.C Vl53l0x_TEST.C AMP01.C TLE5012B.C TLE5012BV2.C AMPLED02V13.C EepromTest.C IOTReaderTest.C AMP01V11.C AMP01V11A2.C AMPLCDV11.C AMPLCDV12.C mfrc522test.C sram_test.C
  group AMP01V11A3
    ../../Examples/WOW/: AMP01V11_PC.C AMP01V11_Cab.C AMP01V11_Layer.C AMP01V11_RFID.C AMP01V11_BackLight.C AMP01V11_Lock.C
  group APP/AMP
    ../../Examples/WOW/: AMP_CAB.C AMP_LAY.C AMP_CABV11.C AMP_CABV11A2.C
  group Lib/STM32F10x
    ../../Library/STM32F10x_StdPeriph_Driver/SCR/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
  group Lib/WOW/USB
    ../../Library/WOW/USB/SCR/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Lib/Startup
    ../../Library/Startup/STM32F10x/: cortexm3_macro.s stm32f10x_vector.s
  group Driver/WOW
    ../../Driver/WOW/SCR/: STM32_096OLED.C STM32_A3987.C STM32_ADC.C STM32_CAN.C STM32_CRC.C STM32_DAC.C STM32_DMA.C STM32_EXTI.C STM32_FLASH.C STM32_GPIO.C STM32_I2C.C STM32_NVIC.C STM32_PWM.C STM32_RCC.C STM32_RTC.C STM32_SDCard.C STM32_SPI.C STM32_SYS.C STM32_SYSLED.C STM32_SYSTICK.C STM32_TIM.C STM32_USART.C STM32_WDG.C STM32_FSMC.C STM32_MCO.C
  group Driver/WOW/USB
    ../../Driver/WOW/USB/: hw_config.c usb_endp.c usb_Initialize.c usb_istr.c usb_pwr.c usb_user.c VirtualCom_desc.c VirtualCom_prop.c VirtualCom_hardware.c VirtualCom_endp.c
  group Driver/Components
    ../../Driver/Components/SCR/: 74HC165.C 74HC595.C A3987.C CD4511.C CS5530.c Dallas.c DRV8801.C DS2401.c EC11Encoder.C font.c GT32L32M0180.C MOTOR.C R61509V.c ILI9326.c SSD1963.C SteepMotor.C SWITCHID.C TM1618.C TM1638.C LCD.c CardReader.c MX25L4006E.C TM1616.C MMC_SD.C NAND.C AT24C02.C IOT5302W.C ST7789V.C MFRC522.C IS62WV51216BLL.C SHT20M.C
    ../../Driver/Components/vl53l0x/: vl53l0x.c
    ../../Driver/Protocol/: I2C.C
  group Driver/Tool
    ../../Driver/Tool/: CRC.C LinkedList.C TOOL.C BMP.C
  group Driver/FatFs
    ../../Driver/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c FatFsAPI.c 移植记录.txt
  group Driver/Protocol
    ../../Driver/Protocol/: SPI_FLASH.C USART_ISP.C swd.c swd_pin.c AMP_PHY.C IIC.C
  group Document
    ../../Document/: C语言printf()输出格式大全.txt note.txt readme.txt USB说明.txt 常用C语言标准库函数.txt 常用头文件.txt 仿真设置 .txt
  group VL53L0X_1.0.2/core
    ../../Driver/Components/VL53L0X_1.0.2/Api/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
  group VL53L0X_1.0.2/platform
    ../../Driver/Components/VL53L0X_1.0.2/Api/platform/src/: vl53l0x_i2c_win_serial_comms.c vl53l0x_platform.c vl53l0x_platform_log.c
target R2A15908SP (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: R2A15908SP +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: R2A15908SP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USART_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: USART_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USART_TEST
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Driver\Tool;..\..\Examples\DEMO\include;..\..\Examples\WOW;.\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32_LCD (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: STM32_LCD +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32_LCD
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Driver\Tool;..\..\Examples\DEMO\include;..\..\Examples\WOW;.\main;..\..\Driver\Tool;..\..\Driver\FatFs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ADC_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: ADC_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ADC_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target DAC_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: DAC_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: DAC_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ADC_Temperature (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: ADC_Temperature +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ADC_Temperature
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CAN_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: CAN_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CAN_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPI_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SPI_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPI_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OFFLINE_ISP (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: OFFLINE_ISP +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: OFFLINE_ISP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CD4511BM_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: CD4511BM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CD4511BM_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PL001V20 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MS0800_PL001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PL001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PC004V10 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MS0800_PC004V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PC004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PM001V20 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MS0800_PM001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MX25L4006E (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MX25L4006E +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MX25L4006E
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TM1618 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: TM1618 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: TM1618
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TM1638_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: TM1638_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: TM1638_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target VirtualCom (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: VirtualCom
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USBtoSPI (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: USBtoSPI +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USBtoSPI
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Driver\Tool;..\..\Examples\DEMO\include;..\..\Examples\WOW;.\main;..\..\Driver\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPItoUSART (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SPItoUSART +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPItoUSART
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SysTick_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SysTick_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SysTick_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SteepMotorTest (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SteepMotorTest +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SteepMotorTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PWM_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PWM_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PwrTest (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PwrTest +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PwrTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TIM_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: TIM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: TIM_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OLED096_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: OLED096_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: OLED096_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LK3U_40MR (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: LK3U_40MR +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: LK3U_40MR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target FX2N_14MR (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FX2N_14MR +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: FX2N_14MR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target A3987_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: A3987_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: A3987_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Buzzer_TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Buzzer_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Buzzer_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SWDTEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SWDTEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SWDTEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CS5530_DEMO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: CS5530_DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CS5530_DEMO
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target FatFsTest (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FatFsTest +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: FatFsTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MmcSDTest (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MmcSDTest +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MmcSDTest
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Examples\DEMO\include;..\..\Examples\WOW;.\main;..\..\Driver\Tool;..\..\Driver\FatFs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target FSMCTest (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FSMCTest +hex
  c flags: OneElfS=1 wLevel=2
  c define: FSMCTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMPTest (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMPTest +hex
  c flags: OneElfS=1 wLevel=2
  c define: AMPTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USBDEMO (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: USBDEMO +hex
  c flags: OneElfS=1 wLevel=2
  c define: USBDEMO
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Examples\DEMO\include;..\..\Examples\WOW;.\main;..\..\Driver\Tool;..\..\Driver\FatFs\source;..\..\Library\WOW\USB\INC;..\..\Driver\WOW\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TLE5012B (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: TLE5012B +hex
  c flags: OneElfS=1 wLevel=2
  c define: TLE5012B
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TLE5012BV2 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: TLE5012BV2 +hex
  c flags: OneElfS=1 wLevel=2
  c define: TLE5012BV2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMPLED02V13 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMPLED02V13 +hex
  c flags: OneElfS=1 wLevel=2
  c define: AMPLED02V13
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Vl53l0x_TEST (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Vl53l0x_TEST +hex
  c flags: OneElfS=1 wLevel=2
  c define: Vl53l0x_TEST
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Examples\DEMO\include;..\..\Examples\WOW;.\main;..\..\Driver\Tool;..\..\Driver\FatFs\source;..\..\Driver\Components\vl53l0x;..\..\Driver\Components\VL53L0X_1.0.2\Api\core\inc;..\..\Driver\Components\VL53L0X_1.0.2\Api\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target EepromTest (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: EepromTest +hex
  c flags: OneElfS=1 wLevel=2
  c define: EepromTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PWM_LED (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PWM_LED +hex
  c flags: OneElfS=1 wLevel=2
  c define: PWM_LED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target IOTReaderTest (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: IOTReaderTest +hex
  c flags: OneElfS=1 wLevel=2
  c define: IOTReaderTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMP01 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMP01 +hex
  c flags: OneElfS=1 wLevel=2
  c define: AMP01
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMP01V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMP01V11 +hex
  c flags: OneElfS=1 wLevel=2
  c define: AMP01V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMP01V11A2 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMP01V11A2 +hex
  c flags: OneElfS=1 wLevel=2
  c define: AMP01V11A2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMP01V11A3 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMP01V11A3 +hex
  c flags: OneElfS=1 wLevel=2
  c define: AMP01V11A3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target AMPLCDV11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMPLCDV11 +hex
  c flags: OneElfS=1 wLevel=1
  c define: AMPLCDV11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target AMPLCDV12 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AMPLCDV12 +hex
  c flags: OneElfS=1 wLevel=1
  c define: AMPLCDV12
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target mfrc522test (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: mfrc522test +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: mfrc522test
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target sram_test (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: sram_test +hex
  c flags: OneElfS=1 wLevel=2
  c define: sram_test
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.1
