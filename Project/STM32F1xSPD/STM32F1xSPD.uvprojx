# Keil uVision project STM32F1xSPD.uvprojx, settings and files
target DEMO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Driver\Tool;..\..\Examples\DEMO\include;..\..\Examples\WOW
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MAIN
    ./main/: main.c STM32_IT.c STM32_WOW.C
  group APP
    ../../Examples/SPD/: SP_FB2.C
  group Lib/STM32F10x
    ../../Library/STM32F10x_StdPeriph_Driver/SCR/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
  group Lib/Startup
    ../../Library/Startup/STM32F10x/: cortexm3_macro.s stm32f10x_vector.s
  group Driver/WOW
    ../../Driver/WOW/SCR/: STM32_096OLED.C STM32_A3987.C STM32_ADC.C STM32_CAN.C STM32_CRC.C STM32_DAC.C STM32_DMA.C STM32_EXTI.C STM32_FLASH.C STM32_GPIO.C STM32_NVIC.C STM32_PWM.C STM32_RCC.C STM32_RTC.C STM32_SDCard.C STM32_SPI.C STM32_SYS.C STM32_SYSLED.C STM32_SYSTICK.C STM32_TIM.C STM32_USART.C STM32_WDG.C STM32_FSMC.C STM32_MCO.C
  group Driver/Components
    ../../Driver/Components/SCR/: 74HC165.C 74HC595.C A3987.C CD4511.C CS5530.c Dallas.c DRV8801.C DS2401.c EC11Encoder.C font.c GT32L32M0180.C MOTOR.C R61509V.c ILI9326.c SSD1963.C SteepMotor.C SWITCHID.C TM1618.C TM1638.C LCD.c CardReader.c MX25L4006E.C TM1616.C MMC_SD.C NAND.C AT24C02.C IOT5302W.C ST7789V.C MFRC522.C IS62WV51216BLL.C SHT20M.C SHT20.C BT459A.C XPT2046.C WDH320S.C
    ../../Driver/Components/vl53l0x/: vl53l0x.c
  group Driver/Tool
    ../../Driver/Tool/: CRC.C LinkedList.C TOOL.C BMP.C
  group Driver/Protocol
    ../../Driver/Protocol/: SPI_FLASH.C USART_ISP.C swd.c swd_pin.c AMP_PHY.C Modbus.C IIC.C
  group Document
    ../../Document/: C语言printf()输出格式大全.txt note.txt readme.txt USB说明.txt 常用C语言标准库函数.txt 常用头文件.txt 仿真设置 .txt
target SP_FB2 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SP_FB2 +hex
  c flags: OneElfS=1 wLevel=2
  c define: SP_FB2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Driver\Protocol;..\..\Examples\DEMO\include;..\..\Examples\SPD;.\main;..\..\Driver\Tool;..\..\Driver\FatFs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.0.1
