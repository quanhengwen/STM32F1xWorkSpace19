# Keil uVision project STM32F1xHC.uvprojx, settings and files
target DEMO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: DEMO
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./main/: main.c STM32_IT.c STM32_WOW.C
  group APP_HC
    ../../Examples/HC/: MS0800_PC004V10.C MS0800_PL001V20.C MS0800_PM001V20.C PC001V10.C PC001V21.C PC001V22.C PC001V25.C PC004V21.C PC006V20.C PC006V21.C PC006V22.C PC012V13.C PC016V20.C PC018V10.C PD002V30.C PD003V11.C PD003VG.C PD004V10.C PD006V20.C PD008V11.C PD010V20.C PD011V10.C PD011V20.C PD014V14.C PD014V15.C PL001V20.C PL006V10.C PL009V31.C PL009V33.C PL010V13.C PL010V15.C PL010V15TEST.C PL010V17.C PL012V11.C PL012V11LCD.C PL012V20.C PL012V30.C PL013V10.C PL013V11.C PL013V20.C PM001V20.C PM004V10.C PD011V20_PD014TEST.C PC001V30HC.C PC004V21HC.C PC004V31HC.C PM001V20HC.C PL009V31HC.C PL009V33HC.C PD010V20CAN.C PC016V20Com.C HCProTest.C PS005V10.C PS005V11.C PD002V30ADC.C PL010V17AMP.C PL012V30AMP.C
  group Lib/STM32F10x
    ../../Library/STM32F10x_StdPeriph_Driver/SCR/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Lib/Startup
    ../../Library/Startup/STM32F10x/: cortexm3_macro.s stm32f10x_vector.s
  group Driver/WOW
    ../../Driver/WOW/SCR/: STM32_096OLED.C STM32_A3987.C STM32_ADC.C STM32_CAN.C STM32_CRC.C STM32_DAC.C STM32_DMA.C STM32_EXTI.C STM32_FLASH.C STM32_GPIO.C STM32_I2C.C STM32_NVIC.C STM32_PWM.C STM32_RCC.C STM32_RTC.C STM32_SDCard.C STM32_SPI.C STM32_SYS.C STM32_SYSLED.C STM32_SYSTICK.C STM32_TIM.C STM32_USART.C STM32_WDG.C STM32_MCO.C
  group Driver/Components
    ../../Driver/Components/SCR/: 74HC165.C 74HC595.C A3987.C CardReader.c CD4051.C CD4511.C CS5530.c Dallas.c DRV8801.C DS2401.c EC11Encoder.C font.c GT32L32M0180.C gui.c MOTOR.C R61509V.c SSD1963.C ILI9326.c SteepMotor.C SWITCHID.C TM1618.C TM1638.C LOCK.C AT24C02.C LCD.c MX25L4006E.C DS18B20.C TM1616.C
  group Driver/Tool
    ../../Driver/Tool/: CRC.C LinkedList.C TOOL.C
  group Driver/Protocol
    ../../Driver/Protocol/: SPI_FLASH.C USART_ISP.C HC_PHY.C HC_RS232.C HC_RS485.C I2C.C OneWrie.C AMP_PHY.C
  group Document
    ../../Document/: C语言printf()输出格式大全.txt note.txt readme.txt USB说明.txt 常用C语言标准库函数.txt 常用头文件.txt 仿真设置 .txt
target MS0800_PC004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MS0800_PC004V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PC004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PL001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MS0800_PL001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PL001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PM001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: MS0800_PM001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC001V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V10
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;..\..\Driver\Protocol;.\main;..\..\Driver\Tool
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V21 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC001V21 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V21
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;..\..\Driver\Protocol;..\..\Driver\Tool;.\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V22 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC001V22 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V22
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;.\main;..\..\Driver\Protocol;..\..\Driver\Tool
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V25 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC001V25 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V25
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;.\main;..\..\Driver\Tool;..\..\Driver\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC004V21 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC004V21 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC004V21
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC006V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC006V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC006V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC006V21 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC006V21 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC006V21
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC006V22 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC006V22 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC006V22
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC012V13 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC012V13 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC012V13
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC016V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC016V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC016V20
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;..\..\Examples\DEMO\include;.\main;..\..\Driver\Tool;..\..\Driver\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC018V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC018V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC018V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD002V30 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD002V30 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD002V30
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD002V30ADC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD002V30ADC +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD002V30ADC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD003V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD003V11 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD003V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD003VG (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD003VG +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD003VG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD004V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD006V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD006V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD006V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD008V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD008V11 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD008V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD010V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD010V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD010V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD011V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD011V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD011V10
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;..\..\Driver\Tool;.\main;..\..\Driver\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD011V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD011V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD011V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD014V14 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD014V14 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD014V14
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD014V15 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD014V15 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD014V15
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL001V20
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;.\main;..\..\Driver\Tool
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL006V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL006V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL006V10
  c include: ..\..\Examples\DEMO\include;..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Driver\WOW\INC;..\..\Driver\Components\INC;..\..\Examples\HC;.\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL009V31 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PL009V31 +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL009V31
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target PL009V33 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL009V33 +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL009V33
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL010V13 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL010V13 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL010V13
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL010V15 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL010V15 +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL010V15
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL010V15TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL010V15TEST +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL010V15TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL010V17 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL010V17 +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL010V17
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL010V17AMP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL010V17AMP +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL010V17AMP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL012V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL012V11 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL012V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL012V11LCD (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL012V11LCD +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL012V11LCD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL012V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL012V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL012V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL012V30 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL012V30 +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL012V30
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL013V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL013V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL013V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL013V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL013V11 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL013V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL013V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL013V11 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL013V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PM001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PM001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PM004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PM004V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PM004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V30HC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC001V30HC +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V30HC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC004V21HC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC004V21HC +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC004V21HC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC004V31HC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC004V31HC +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC004V31HC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PM001V20HC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PM001V20HC +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PM001V20HC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL009V31HC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL009V31HC +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL009V31HC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target PL009V33HC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL009V33HC +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL009V33HC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD010V20CAN (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PD010V20CAN +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD010V20CAN
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC016V20Com (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PC016V20Com +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC016V20Com
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HCProTest (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: HCProTest +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: HCProTest
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PS005V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PS005V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PS005V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PS005V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PS005V11 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PS005V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL012V30AMP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: PL012V30AMP +hex
  c flags: OneElfS=1 wLevel=2
  c define: PL012V30AMP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.0
